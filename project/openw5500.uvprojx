# Keil uVision project openw5500.uvprojx, settings and files
target openw5500 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103ZE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x10000) IROM(0x08000000,0x80000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: openw5500 +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD,USE_STDPERIPH_DRIVER
  c include: ..\src\common;..\src\dev;..\src\drv;..\src\util;..\STM32F10x_StdPeriph_Driver\inc;..\startup
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group startup
    ../startup/: core_cm3.c system_stm32f10x.c stm32f10x_it.c startup_stm32f10x_hd.s
  group stm32f1_stdlib
    ../STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_spi.c stm32f10x_usart.c
  group common
    ../src/common/: datastruct.c
  group main
    ../src/main/: main.c
  group drv
    ../src/drv/: drv_spi.c drv_util.c drv_board.c drv_usart.c
  group dev
    ../src/dev/: dev_w5500.c
  group util
    ../src/util/: dhcp.c dns.c util.c
